# Keil uVision project assignment1new.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51CC03 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x7FF) CLOCK(33000000) MODP2
  output: assignment1new +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c assem.a51
